## drivers/net/wireless/rtl8703bs/Kconfig
```kconfig
config RTL8703BS
	tristate "Realtek 8723C SDIO or SPI WiFi"
	---help---
	  Help message of RTL8723CS
```
